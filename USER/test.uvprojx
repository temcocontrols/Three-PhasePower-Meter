# Keil uVision project test.uvprojx, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PowerMeter +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\STMFLASH;..\HARDWARE\TIMER;..\HARDWARE\ENC28J60;..\uIP-1.0\uip;..\uIP-1.0\apps\dhcpc;..\uIP-1.0\apps\resolv;..\uIP-1.0\apps\webserver;..\uIP-APP;..\HARDWARE\RTC;..\MODBUS;..\TCPIP;..\KEY;..\FILTER;..\RANGE;..\bacnet;..\bacnet\include;..\INPUT_LIB;..\STORE_DATA;..\INFO;..\INPUT;..\baclib;..\baclib\object;..\baclib\include;..\HARDWARE\ADE7753;..\IO_control
  memory RVCT4: ROM 0x8008000 size 0x60000
  memory RVCT6: RAM 0x60000000 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c FreeRTOSConfig.h
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c
  group CMSIS
    ../CORE/: cortexm3_macro_rvds.s core_cm3.c startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/TIMER/: timerx.c
    ../HARDWARE/ENC28J60/: enc28j60.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/ADE7753/: ADE7753.c
  group FREERTOS
    ../FreeRTOS/: tasks.c list.c queue.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group UIP-1.0
    ../uIP-1.0/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group UIP-APP
    ../uIP-APP/: clock-arch.c tapdev.c tcp_demo.c tcp_modbus.c udp_scan.c
    ../uIP-1.0/apps/dhcpc/: dhcpc.c
    ../uIP-1.0/apps/resolv/: resolv.c
  group MODBUS
    ../MODBUS/: modbus.c modbus_crc.c
  group INFO
    ../INFO/: info.c
  group IO
    ../IO_control/: IO_control_ARM_rev12.lib io_example.c analog_input.c analog_output.c
  group BACNET
    ../baclib/: store.c bacnet_function.c bip.c bacnet_ARM_with_bip_rev8.lib
